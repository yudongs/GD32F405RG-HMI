# Keil uVision project GD32F405RG.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F405RG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F405RG +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F405,USE_STDPERIPH_DRIVER,USE_USB_FS,USE_RTT,USE_VTFP=1
  c misc: --preinclude=..\generated\vtfp_compat.h
  c include: ..\CMSIS\GD\GD32F4xx\Include;..\GD32_StdPeriph_Driver\Include;..\CMSIS;..\User;..\APP;..\FreeRTOS\include;..\FreeRTOS\Source\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\VTFP\vtfp-protocol\c-types;..\VTFP\vtfp-runtime\include;..\VTFP\vtfp-runtime\src\ports;..\generated
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: core_cm4.h
    ../CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f405_425.s
    ../CMSIS/GD/GD32F4xx/Include/: gd32f4xx.h system_gd32f4xx.h
  group GD32_StdPeriph_Driver
    ../GD32_StdPeriph_Driver/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group User
    ../User/: main.c
  group RTT
    ../src/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group APP
    ../APP/: lcd_st7586.c lcd_test.c key.c menu.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_Portable
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group VTFP
    ../VTFP/vtfp-protocol/c-types/: vtfp_crc.c
    ../VTFP/vtfp-runtime/src/: vtfp_core.c vtfp_checksum.c vtfp_arm.c vtfp_dispatch.c
    ../VTFP/vtfp-runtime/src/ports/: vtfp_port_freertos.c
    ../generated/: vtfp_user_dispatch.c
